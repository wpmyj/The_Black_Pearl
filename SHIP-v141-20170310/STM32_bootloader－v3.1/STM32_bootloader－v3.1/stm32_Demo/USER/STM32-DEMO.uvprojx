# Keil uVision project STM32-DEMO.uvprojx, settings and files
target STM32-DEMO (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWlib\inc;..\Output;..\USER;..\FWlib\src;..\delay;..\usart1;..\LCD;..\GUI;..\SPI_SD;..\SD;..\src;..\src\option;..\STMFLASH;..\IAP;..\led;..\secret
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
    ../usart1/: usart1.c
    ../spi_sd/: spi_sd.c
    ../led/: bsp_led.c
    ../secret/: secret.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_flash.c
  group delay
    ../delay/: delay.c
  group sd
    ../SD/: MMC_SD.C
  group Fatfs
    ../src/: ff.c diskio.c
    ../src/option/: cc936.c
  group STMFLASH
    ../STMFLASH/: stmflash.c
  group IAP
    ../IAP/: iap.c
  group Doc
    ../Doc/: version.txt
