# Keil uVision project SHIP.uvprojx, settings and files
target SHIP (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SHIP
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  .\TEST.bin  .\Objects\SHIP.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,STM32F103VCT6_MCU
  c include: .\Libraries\FWlib\inc;.\User\adc;.\User\gps;.\User\Key;.\User\L9110;.\User\led;.\User\manager;.\User\moto;.\User\nmea_decode\include;.\User\OLED;.\User\PwmOutput;.\User\secret;.\User\stack;.\User\Stop_Mode;.\User\SysTick;.\User\temperature;.\User\TIM5;.\User\usart;.\User\wwdog;.\Libraries\CMSIS\startup;.\Libraries\CMSIS;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./User/: main.c stm32f10x_it.c
    ./User/adc/: bsp_adc.c
    ./User/gps/: gps_config.c
    ./User/Key/: bsp_key.c
    ./User/L9110/: L9110S.c
    ./User/led/: bsp_led.c
    ./User/manager/: manager.c
    ./User/moto/: moto.c
    ./User/OLED/: oled.c
    ./User/PwmOutput/: bsp_pwm_output.c
    ./User/secret/: secret.c
    ./User/stack/: linkstack.c
    ./User/Stop_Mode/: stop_mode.c
    ./User/SysTick/: bsp_SysTick.c
    ./User/temperature/: temperature.c
    ./User/TIM5/: TIM5.c
    ./User/usart/: bsp_usart.c
    ./User/wwdog/: bsp_wwdg.c
  group FWLIB
    ./Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group NEMALIB
    ./User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group DOC
    ./readme/: readme.txt
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
